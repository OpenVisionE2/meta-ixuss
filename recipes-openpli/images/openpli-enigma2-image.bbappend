IMAGE_INSTALL_remove_ixussone = " \
	rt7777 \
	"

IMAGE_INSTALL_remove_ixusszero = " \
	rt7777 \
	"
